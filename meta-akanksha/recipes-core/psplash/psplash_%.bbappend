FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://psplash-poky-img.png"